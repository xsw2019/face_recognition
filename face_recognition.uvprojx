# Keil uVision project face_recognition.uvprojx, settings and files
target face_recognition (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: face_recognition
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F470
  c include: .eide\deps;..\..\GD32F4\GD32F4xx_Firmware_Library_V3.0.4\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\GD32F4\GD32F4xx_Firmware_Library_V3.0.4\Firmware\GD32F4xx_standard_peripheral\Include;..\..\GD32F4\GD32F4xx_Firmware_Library_V3.0.4\Firmware\CMSIS;User;TinyMaix;TinyMaix\include;TinyMaix\src;Hardware
  asm define: GD32F470
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HARDWARE
    Hardware/: systick.c usart.c
  group USER
    User/: gd32f4xx_it.c main.c
  group TINYMAIX
    TinyMaix/: cnn_face_main.c main_classification.c
  group TINYMAIX/SRC
    TinyMaix/src/: tm_layers.c tm_layers_fp8.c tm_layers_O1.c tm_model.c tm_stat.c
  group Firmware
    ../../GD32F4/GD32F4xx_Firmware_Library_V3.0.4/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ../../GD32F4/GD32F4xx_Firmware_Library_V3.0.4/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../../GD32F4/GD32F4xx_Firmware_Library_V3.0.4/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
